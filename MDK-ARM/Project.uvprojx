# Keil uVision project Project.uvprojx, settings and files
target SX1212 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F051C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: SX1212_test +hex
  AfterMake: fromelf.exe --bin -o  .\Bin\SX1212_Debug.bin .\Objects\SX1212_Debug.axf
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F051,STM32F0XX,CODE_RELEASE,
  c include: ..\STM32Lib\STM32_Device_Lib\STM32F0xx_StdPeriph_Driver\inc;..\STM32Lib\STM32_Device_Lib\CMSIS\CM0\Include;..\STM32Lib\STM32_Device_Lib\CMSIS\CM0\Device\ST\STM32F0xx\Include;..\STM32Lib\UserLib\CLI\inc;..\STM32Lib\UserLib\cpu\inc;..\STM32Lib\UserLib\device\inc;..\STM32Lib\UserLib\Protocol\inc;..\STM32Lib\UserLib\serial_lib\inc;..\STM32Lib\UserLib\user\inc;..\STM32Lib\UserLib\utilities\inc;..\STM32Lib\UserLib\debug\inc;..\STM32Lib\UserLib\Queue\inc;..\app\inc;..\STM32Lib\UserLib\CookerParse
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ../STM32Lib/STM32_Device_Lib/CMSIS/CM0/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s startup_stm32f0xx_ld.s startup_stm32f030.s startup_stm32f031.s startup_stm32f042.s startup_stm32f051.s startup_stm32f072.s
  group CMSIS
    ../STM32Lib/STM32_Device_Lib/CMSIS/CM0/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group App
    ../app/src/: app.c GasStove_Service.c
    ../app/inc/: Package_SX1212.h
  group CPU
    ../STM32Lib/UserLib/cpu/src/: STM32Fxxx_Serial.c STM32Fxxx_Misc.c STM32Fxxx_RTC.c STM32Fxx_Flash.c
    ../STM32Lib/UserLib/cpu/inc/: STM32Fxxx_RTC.h
  group FWLib
    ../STM32Lib/STM32_Device_Lib/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
    ../STM32Lib/STM32_Device_Lib/STM32F0xx_StdPeriph_Driver/inc/: stm32f0xx_adc.h stm32f0xx_can.h stm32f0xx_cec.h stm32f0xx_comp.h stm32f0xx_crc.h stm32f0xx_crs.h stm32f0xx_dac.h stm32f0xx_dbgmcu.h stm32f0xx_dma.h stm32f0xx_exti.h stm32f0xx_flash.h stm32f0xx_gpio.h stm32f0xx_i2c.h stm32f0xx_iwdg.h stm32f0xx_misc.h stm32f0xx_pwr.h stm32f0xx_rcc.h stm32f0xx_rtc.h stm32f0xx_spi.h stm32f0xx_syscfg.h stm32f0xx_tim.h stm32f0xx_usart.h stm32f0xx_wwdg.h
  group Device
    ../STM32Lib/UserLib/device/src/: SX1212.c ChordTone.c KeyBoard.c HT1621.c
    ../STM32Lib/UserLib/device/inc/: SX1212.h ChordTone.h KeyBoard.h
  group Driver
    ../STM32Lib/UserLib/device/src/: rtc.c
  group Cooker_Parse
    ../STM32Lib/UserLib/CookerParse/: Cooker_ExtAFN.c Cooker_Parse.c Cooker_Parse.h
  group platform
    ../platform/: platform_SX1212.c platform_ChordTone.c platform_ExtPin.c platform_HT1621.c
  group utilities
    ../STM32Lib/UserLib/utilities/src/: utilities.c Crc32EthernetSTM32.c StringOperate.c crc.c
